Commit message: Update from Lewis Branch

File: workspace/packages/sub_launch/urdf/asuqtr_sub.urdf (robot description, URDF)
Before this commit: robot sub, 4 links, 3 joints
Joints:
- joint base_to_vectornav_imu: origin xyz=0.00 0.0 -0.0475 rpy=3.14159 0.0 0.0 -> xyz=0.00 0.0 -0.0475 rpy=0 0.0 0.0
