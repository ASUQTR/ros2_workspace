Commit message: modify urdf to account for x offset of depth sensor

File: src/sub_launch/urdf/asuqtr_sub.urdf (robot description, URDF)
Before this commit: robot sub, 4 links, 3 joints
Joints:
- joint base_to_bar30: origin xyz=0.0 0.0 0.0525 rpy=0.0 0.0 0.0 -> xyz=0.2 0.0 0.0525 rpy=0.0 0.0 0.0
